Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-04-25T11:28:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 11:28:03 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\0af687aa-8a1c-4118-bf28-480f9291d633\81d8ce04-3e7c-4aea-982f-df2488dfa391\ifc * Database version: 5507 * Database creation date: Thu Apr 25 11:28:02 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 11:28:03 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 11:28:03 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12635820_USA_CVA7875_GRGR:29787530_USA_12635820_CVA7875_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_GRGR, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 29787530_USA_12635820_CVA7875_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29787530_USA_12635820_CVA7875_GRGR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 475 mm

# IfcDistributionPort, Port_353128
Description: Flow; FlowDirection: SOURCEANDSINK
